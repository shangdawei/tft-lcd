# IAR project alamr1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C4 STM8S105C4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: inc\; C:\Program Files\IAR Systems\Embedded Workbench 6.0 Evaluation\stm8\examples\ST-LINK\STM8S105C6-Board\Libraries\STM8S_StdPeriph_Driver\inc\; C:\Program Files\IAR Systems\Embedded Workbench 6.0 Evaluation\stm8\examples\ST-LINK\STM8S105C6-Board\Project\Discover\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: alamr1.srec
  ILINK.IlinkOutputFile: yyy.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: alamr1.out
  group (top)
    src/: alarm.c board.c decode.c device.c key.c led.c main.c
    $EW_DIR$/stm8/examples/ST-LINK/STM8S105C6-Board/Debug/Exe/: FWLib.a
